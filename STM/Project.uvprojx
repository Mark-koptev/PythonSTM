# Keil uVision project Project.uvprojx, settings and files
target STM32F3-Discovery (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F3-Discovery
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: .\STM32F3xx_LL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group STM32F3xx_LL_Driver
    ./STM32F3xx_LL_Driver/Src/: stm32f3xx_ll_exti.c stm32f3xx_ll_gpio.c stm32f3xx_ll_rcc.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c
  group User
    ./User/: main.c stm32f3xx_it.c AsciiLib.c lcd_ILI9325.c systickms.c keypad.c display.c Settings.h Draw.h Draw.c Images.c Images.h StateSystem.c StateSystem.h SnakeMovementState.h SnakeMovementState.c MenuState.c MenuState.h SnakePart.c SnakePart.h AppleGenerator.c AppleGenerator.h States.h GameOverState.h GameOverState.c AsciiLib.h display.h keypad.h LCD_ILI9325.h main.h stm32f3xx_it.h systickms.h uart.c uart.h WallGenerator.c WallGenerator.h WallPatterns.c Button.h SoundManager.c SoundManager.h Button.c States.c ExampleState.h ExampleState.c
software components: CMSIS:CORE 5.5.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.11.3
